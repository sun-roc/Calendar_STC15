# Keil uVision project PerpetualCalendar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: PerpetualCalendar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Source/: calendar.h character.h clock.h key.h lcd.h sensor.h Main.c
